# Keil uVision project SW_DP11_INIT.uvprojx, settings and files
target SW_DP11_INIT (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: SW_DP11_INIT +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,QSPI_CLOCK_PRESCALER=2,QSPI_DDRMODE,QSPI_XIP_MODE
  c include: ../Core/Inc;               ../TouchGFX/target;               ../TouchGFX/generated/fonts/include;               ../TouchGFX/generated/texts/include;               ../TouchGFX/generated/images/include;               ../TouchGFX/generated/gui_generated/include;               ../TouchGFX/gui/include;../middlewares/st/touchgfx/touchgfx/framework/include;               ../Drivers/STM32F7xx_HAL_Driver/Inc;               ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;               ../Middlewares/Third_Party/FreeRTOS/Source/include;               ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;               ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;               ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;               ../Drivers/CMSIS/Include;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include;../middlewares/st/touchgfx/touchgfx/framework/include
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: SW_DP11_INIT\SW_DP11_INIT.sct
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp gpio.c adc.c can.c crc.c dma.c freertos.c i2c.c quadspi.c spi.c tim.c stm32f7xx_it.c stm32f7xx_hal_msp.c stm32f7xx_hal_timebase_tim.c stm32756g_eval_qspi.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp STM32F7DMA.cpp STM32F7HAL.cpp STM32F7TouchController.cpp STM32F7Instrumentation.cpp HW_Init.cpp
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma2d.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_spi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/TouchGFX
    ../middlewares/st/touchgfx/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
    ../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
  group Application/User/TouchGFX/gui
    ../touchgfx/gui/src/acceleration_screen/: accelerationpresenter.cpp accelerationview.cpp
    ../touchgfx/gui/src/autocross_screen/: autocrosspresenter.cpp autocrossview.cpp
    ../touchgfx/gui/src/board_debug_screen/: board_debugpresenter.cpp board_debugview.cpp
    ../touchgfx/gui/src/debug_mode_screen/: debug_modepresenter.cpp debug_modeview.cpp
    ../touchgfx/gui/src/endurance_screen/: endurancepresenter.cpp enduranceview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/screen1_screen/: screen1presenter.cpp screen1view.cpp
    ../touchgfx/gui/src/settings_screen/: settingspresenter.cpp settingsview.cpp
    ../touchgfx/gui/src/skidpad_screen/: skidpadpresenter.cpp skidpadview.cpp
  group Application/User/TouchGFX/generated
    ../touchgfx/generated/gui_generated/src/acceleration_screen/: accelerationviewbase.cpp
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp font_roboto_bold_20_4bpp.cpp font_roboto_bold_25_4bpp.cpp font_roboto_regular_180_4bpp.cpp font_roboto_regular_25_4bpp.cpp font_roboto_regular_420_4bpp.cpp font_roboto_regular_63_4bpp.cpp fontgetters.cpp kerning_roboto_bold_20_4bpp.cpp kerning_roboto_bold_25_4bpp.cpp kerning_roboto_regular_180_4bpp.cpp kerning_roboto_regular_25_4bpp.cpp kerning_roboto_regular_420_4bpp.cpp kerning_roboto_regular_63_4bpp.cpp table_roboto_bold_20_4bpp.cpp table_roboto_bold_25_4bpp.cpp table_roboto_regular_180_4bpp.cpp table_roboto_regular_25_4bpp.cpp table_roboto_regular_420_4bpp.cpp table_roboto_regular_63_4bpp.cpp
    ../touchgfx/generated/gui_generated/src/autocross_screen/: autocrossviewbase.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp
    ../touchgfx/generated/gui_generated/src/board_debug_screen/: board_debugviewbase.cpp
    ../touchgfx/generated/gui_generated/src/debug_mode_screen/: debug_modeviewbase.cpp
    ../touchgfx/generated/gui_generated/src/endurance_screen/: enduranceviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/screen1_screen/: screen1viewbase.cpp
    ../touchgfx/generated/gui_generated/src/settings_screen/: settingsviewbase.cpp
    ../touchgfx/generated/gui_generated/src/skidpad_screen/: skidpadviewbase.cpp
software components: CMSIS:CORE 4.3.0
